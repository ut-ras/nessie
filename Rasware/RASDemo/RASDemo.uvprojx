# Keil uVision project RASDemo.uvprojx, settings and files
target RASDemo (5060020::V5.06 (build 20)::ARMCC)
  device: LM4F120H5QR Texas Instruments
  pack: Keil.LM4F_DFP.1.0.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x10000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RASDemo
  c flags: Optim=1
  c include: ..\;..\..\;C:\;..\StellarisWare;..\..\StellarisWare;C:\StellarisWare;inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  link misc: --entry=ResetHandler --first=__Vectors --datacompressor=off
  group Source
    ./: EncoderDemo.c IRSensorDemo.c Main.c MotorDemo.c ServoDemo.c UARTDemo.c Startup.c GPIODemo.c SonarDemo.c GPIOLineSensorDemo.c I2CLineSensorDemo.c
  group Libs
    ../RASLib/output/: RASLib.lib
software components: CMSIS:CORE 4.1.0
